# IAR project PC_TW.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: starand lib\inc; starand lib\src; Application
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: PC_TW.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
configuration TW_40W (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: OT_TW_40W; EXTERN_INTERRUPT
  OBJCOPY.OOCOutputFile: PC_TW.hex
  group Application
    Application/: hal_digital.c hal_digital.h main.c TW_40W.h
  group Libarary/inc
    starand lib/inc/: stm8s.h stm8s_adc1.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_it.h stm8s_itc.h stm8s_iwdg.h stm8s_tim1.h stm8s_uart1.h stm8s_wwdg.h
  group Libarary/src
    starand lib/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
